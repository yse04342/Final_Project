# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries; Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: E:\test\Libraries\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARM
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group GUI
    Libraries/: Gulim10_8x16_ASCII.c Gulim20_16x34_ASCII.c Gulim28_24x48_ASCII.c Gulim7_6x10_ASCII.c Gulim8_8x12_ASCII.c
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c
  group TM
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c tm_stm32f4_dma.c tm_stm32f4_fonts.c tm_stm32f4_gpio.c tm_stm32f4_ili9341.c tm_stm32f4_spi.c tm_stm32f4_spi_dma.c
  group User
    ./: FOD_Cleaner.c
    Libraries/: Util.c
